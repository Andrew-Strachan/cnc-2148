# IAR project cnc-2148.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC2148 NXP LPC2148
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 1
  General.FPU2: 0
  ICCARM.CCIncludePath2: C:\Users\strac\Source\Repos\cnc-2148\inc; C:\Users\strac\Source\Repos\cnc-2148\inc\USB
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: handler.c jogmovement.c LPC_SysControl.c main.cpp motor.cpp MotorConfig.cpp movement.cpp
  group USB
    USB/: cd_class.c usb_buffer.c usb_dev_desc.c usb_hooks.c usb_hw.c usb_t9.c
